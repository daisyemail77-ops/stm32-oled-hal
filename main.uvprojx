# Keil uVision project main.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: STM32F103xB,USE_HAL_DRIVER
  c misc: -ffunction-sections -fdata-sections
  c include: .\;.\HAL\Inc;.\Device\Include;.\U8g2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./HAL/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_i2c.c
    ./Device/Source/: system_stm32f1xx.c
    ./: main.c aht20.c font_hz16.c font_asc8x16.c
    ./Device/Startup/: startup_stm32f103xb.s
    ./U8g2/: u8g2_setup.c u8g2_buffer.c u8g2_box.c u8g2_bitmap.c u8g2_cleardisplay.c u8g2_font.c u8g2_kerning.c u8g2_hvline.c u8g2_ll_hvline.c u8g2_line.c u8g2_intersection.c u8g2_circle.c u8g2_d_setup.c u8g2_d_memory.c u8x8_setup.c u8x8_display.c u8x8_byte.c u8x8_cad.c u8x8_gpio.c u8x8_d_ssd1306_128x64_noname.c u8x8_capture.c u8x8_string.c u8x8_8x8.c u8x8_u16toa.c
software components: CMSIS:CORE 6.2.0
